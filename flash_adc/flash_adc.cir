* R:\esim_simulations\gurubaran\flash_adc\flash_adc.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 03/10/22 21:43:17

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
R1  vref Net-_R1-Pad2_ 1k
R2  Net-_R1-Pad2_ Net-_R2-Pad2_ 1k
R3  Net-_R2-Pad2_ Net-_R3-Pad2_ 1k
R4  Net-_R3-Pad2_ Net-_R4-Pad2_ 1k
R5  Net-_R4-Pad2_ Net-_R5-Pad2_ 1k
R6  Net-_R5-Pad2_ Net-_R6-Pad2_ 1k
R7  Net-_R6-Pad2_ Net-_R7-Pad2_ 1k
R8  Net-_R7-Pad2_ GND 1k
X6  ? Net-_R1-Pad2_ vin vss ? Net-_U2-Pad1_ vcc ? lm_741
X7  ? Net-_R2-Pad2_ vin vss ? Net-_U2-Pad2_ vcc ? lm_741
X3  ? Net-_R3-Pad2_ vin vss ? Net-_U2-Pad3_ vcc ? lm_741
X4  ? Net-_R4-Pad2_ vin vss ? Net-_U2-Pad4_ vcc ? lm_741
X5  ? Net-_R5-Pad2_ vin vss ? Net-_U2-Pad5_ vcc ? lm_741
X1  ? Net-_R6-Pad2_ vin vss ? Net-_U2-Pad6_ vcc ? lm_741
X2  ? Net-_R7-Pad2_ vin vss ? Net-_U2-Pad7_ vcc ? lm_741
v2  vcc GND DC
v3  GND vss DC
v4  vref GND DC
U1  Net-_U1-Pad1_ Net-_U1-Pad2_ Net-_U1-Pad3_ Net-_U1-Pad4_ Net-_U1-Pad5_ Net-_U1-Pad6_ Net-_U1-Pad7_ Net-_U1-Pad8_ Net-_U1-Pad9_ Net-_U1-Pad10_ Net-_U1-Pad11_ guru_encoder
U2  Net-_U2-Pad1_ Net-_U2-Pad2_ Net-_U2-Pad3_ Net-_U2-Pad4_ Net-_U2-Pad5_ Net-_U2-Pad6_ Net-_U2-Pad7_ GND Net-_U1-Pad1_ Net-_U1-Pad2_ Net-_U1-Pad3_ Net-_U1-Pad4_ Net-_U1-Pad5_ Net-_U1-Pad6_ Net-_U1-Pad7_ Net-_U1-Pad8_ adc_bridge_8
U3  Net-_U1-Pad9_ Net-_U1-Pad10_ Net-_U1-Pad11_ out2 out1 out0 dac_bridge_3
U4  out2 plot_v1
U6  out1 plot_v1
U5  out0 plot_v1
v1  vin GND DC

.end
